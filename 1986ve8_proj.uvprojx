# Keil uVision project 1986ve8_proj.uvprojx, settings and files
target Target (IntRAM) (ARM-ADS)
  device: MDR32F8 Milandr
  pack: Keil.MDR1986VE8T.0.4.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x20006000,0x2000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: 1986ve8_proj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: _INT_RAM_
  memory RVCT4: ROM 0x20006000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Source Group 1
    ./Sources/: sysinit.c main.c uarts.c wdt.c debug.c adc.c timers.c dac.c gpio.c termo_res.c oai_dd.c mpi.c bdd.c bdd_mpi_interface.c mvip.c digital_filter.c ims.c
  group 1986ve8_lib
    ./Sources/1986ve8_lib/: core_cm4.c startup_MDR1986VE8T.s
target Target (ExtMEM Dbg) (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR32F8 Milandr
  pack: Keil.MDR1986VE8T.0.4.1
  cpu: as above
  output: 1986ve8_proj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT1: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Target (ExtMEM Rls) (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR32F8 Milandr
  pack: Keil.MDR1986VE8T.0.4.1
  cpu: as above
  output: 1986ve8_proj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: _EXT_MEM_RLS_
  memory RVCT1: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 5.4.0
